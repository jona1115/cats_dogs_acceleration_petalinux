BRANCH= "2023.1"
SRCREV= "46b354a124c9f003a8e6ea1b95041a5805436449"
PV = "202310.2.15.0"
# For why this PV see: https://github.com/Xilinx/XRT/blob/master/CHANGELOG.rst