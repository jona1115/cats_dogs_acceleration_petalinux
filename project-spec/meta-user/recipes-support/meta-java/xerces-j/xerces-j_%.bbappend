# There is a bug in the meta-java repo, see: https://github.com/jona1115/cats_dogs_acceleration/tree/main/documentations/vivadoTRD_and_Petalinux#java

# Fix:
SRC_URI = "http://ftp.deu.edu.tr/pub/Infosystem/Apache/xerces/j/source/Xerces-J-src.${PV}.tar.gz"

