EXTRA_OECONF += "\
    --disable-install-doc \
"